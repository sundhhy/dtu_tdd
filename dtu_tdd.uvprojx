# Keil uVision project dtu_tdd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dtu_tdd
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL,HSE_VALUE=8000000
  c misc: --diag_suppress=1295
  c include: .\lw_oopc_v1.2;.\class;.\BSP;..\dtu_tdd;.\sdh_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c cdma_dtu.c Thread_rtu.c dtuConfig.h
  group class
    ./class/: gprs.c gprs.h stm32ADC.c stm32ADC.h led.c led.h
  group bsp
    ./BSP/: hardwareConfig.c hardwareConfig.h chipset.c debug.c debug.h gprs_uart.c gprs_uart.h serial485_uart.c serial485_uart.h spi.c spi.h times.c adc.c adc.h
  group sdh_lib
    ./sdh_lib/: hw_w25q.h hw_w25q.c CircularBuffer.c sw_filesys.c sw_filesys.h list.c TTextConfProt.c Ping_PongBuf.c modbusRTU_cli.c modbusRTU_cli.h
software components: CMSIS:CORE 4.2.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.79.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
